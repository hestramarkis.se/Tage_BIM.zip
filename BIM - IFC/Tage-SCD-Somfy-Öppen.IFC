Properties of the parts of a building model (IFC4)

# File
Description: IFC4
File name: Tage-SCD-Somfy-Öppen.IFC
Time: 2025-01-13T11:05:14
Written by: SwIFC
Made in: SolidWorks 2023

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBuildingElementProxy: 10039
In: Default Storey
PredefinedType: ELEMENT; Material: ABS

# IfcBuildingElementProxy: 10043
In: Default Storey
PredefinedType: ELEMENT; Material: ABS

# IfcBuildingElementProxy: 10398_Tage
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: 10399_Tage
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: 10406_Tage
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: 20000 (2)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: 20025_4.2x19 TX KFTS Skruv (8)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: 20032_M6 Flänsmutter (2)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: 20049 (2)
In: Default Storey
PredefinedType: ELEMENT; Material: Steel

# IfcBuildingElementProxy: 20104 (8)
In: Default Storey
PredefinedType: ELEMENT
Name | Material
4 x 20104 | 0
4 x 20104 | Steel

# IfcBuildingElementProxy: 30156_100cm Tage
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: 30160_100cm Tage Becker
In: Default Storey
PredefinedType: ELEMENT; Material: 6060-F22 (Hydro)

# IfcBuildingElementProxy: 30162_100cm SCD Becker
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: 30192_Arm 50 (2)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: 40232
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: 40366
In: Default Storey
PredefinedType: ELEMENT; Material: Alu. Alloy, cast

# IfcBuildingElementProxy: 40383
In: Default Storey
PredefinedType: ELEMENT; Material: ABS

# IfcBuildingElementProxy: 40520
In: Default Storey
PredefinedType: ELEMENT; Material: Alu. Alloy, cast

# IfcBuildingElementProxy: 40667-1
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: 40667-2 (4)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: 40705_Höger
In: Default Storey
PredefinedType: ELEMENT; Material: Alu. Alloy, cast

# IfcBuildingElementProxy: 40706_Vänster
In: Default Storey
PredefinedType: ELEMENT; Material: Alu. Alloy, cast

# IfcBuildingElementProxy: 40733 (2)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: 40735_Solcell vänster
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: 40736
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: 40737-1_Batteri bak
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: 40737-2 (2)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: 732002 (2)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: 732004 (2)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: 732005 (2)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: 732006 (2)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: 732007 (2)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: 732008 (2)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: 732009 (2)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: 732010 (2)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: 732011 (2)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: 90044
In: Default Storey
PredefinedType: ELEMENT; Material: Steel

# IfcBuildingElementProxy: Buntband 10
In: Default Storey
PredefinedType: ELEMENT; Material: Steel

# IfcBuildingElementProxy: ISO 14583 M6 x 20_7045 8 -6 20-mattssons (2)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Tage-Kappa_Tage-M 2mm tjocklek
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Tage-M-Väv_Nere
In: Default Storey
PredefinedType: ELEMENT; Material: Steel
